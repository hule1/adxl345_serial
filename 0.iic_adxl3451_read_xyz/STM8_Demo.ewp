# IAR project STM8_Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208MB STM8S208MB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: user; E:\stm8_project\adxl345\adxl345_serial\0.iic_adxl3451_0
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8_Demo.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c pbdata.c pbdata.h
  group user
    user/: adxl345.c adxl345.h iic.c iic.h usart.c usart.h
